# IAR project STM32_F407.ewp, settings and files
configuration STM32_F407 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; HAL_UART_MODULE_ENABLED; STM32F407xx; USE_FULL_LL_DRIVER; HAL_I2C_MODULE_ENABLED
  ICCARM.CCIncludePath2: Source; Source/board; Source/workstates; Source/workstates/common; Source/workstates/device_logic; Source/workstates/device_object; Drivers/STM32F4xx_HAL_Driver/Inc; Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; Middlewares/Third_Party/FatFs/src; Drivers/CMSIS/Device/ST/STM32F4xx/Include; Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sd_spi.hex
  ILINK.IlinkOutputFile: sd_spi.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    source/: main.c main.h
  group board
    source/board/: board_i2c.c board_i2c.h board_init.c board_init.h board_uart.c stm32f4xx_it.c stm32f4xx_it.h TIM6.c TIM6.h USER_SPI.c USER_SPI.h
  group Drivers/CMSIS
    ./: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_rcc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usart.c
  group StartApp
    ./: startup_stm32f407xx.s
  group workstates/common
    source/workstates/common/: common.h simple_queue.c simple_queue.h user_typedef.h
  group workstates/device_logic
    source/workstates/device_logic/: device_logic.c device_logic.h
  group workstates/device_object
    source/workstates/device_object/: device_object.c device_object.h
